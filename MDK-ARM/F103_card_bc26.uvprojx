# Keil uVision project F103_card_bc26.uvprojx, settings and files
target F103_card_bc26 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: F103_card_bc26 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,AUTH_WITH_NOTLS,AUTH_MODE_KEY,MQTT_COMM_ENABLED,MQTT_DEVICE_SHADOW
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Src/lcd/inc;../Src/net_by_at/inc;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/platform;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/device/include;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/mqtt/include;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/sdk-impl;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/utils/digest;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/utils/farra;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/utils/lite;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/sdk-impl/exports;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/platform/os/freertos/include;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/shadow/include
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c list.c timers.c queue.c croutine.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group NetByAt
    ../Src/net_by_at/: at_driver.c at_for_bc26.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: stm32f1xx_it.c stm32f1xx_hal_timebase_TIM.c main.c stm32f1xx_hal_msp.c freertos.c board.c retarget.c peripheral_drv.c stm32f10x_flash.c equip.c
    ../Src/lcd/: lcd.c
  group qcloud_kit
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/utils/lite/: json_parser.c json_token.c string_utils.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/utils/farra/: utils_list.c utils_net.c utils_timer.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/utils/digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/device/src/: device.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/mqtt/src/: mqtt_client.c mqtt_client_common.c mqtt_client_connect.c mqtt_client_net.c mqtt_client_publish.c mqtt_client_subscribe.c mqtt_client_unsubscribe.c mqtt_client_yield.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/sdk-impl/: qcloud_iot_sdk_impl.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/platform/os/freertos/: qcloud_iot_hal_os.c qcloud_iot_hal_tcp.c qcloud_iot_hal_timer.c qcloud_iot_hal_udp.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/shadow/src/: shadow_client.c shadow_client_common.c shadow_client_json.c shadow_client_manager.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_spi.c stm32f1xx_hal_dma.c stm32f1xx_hal_spi_ex.c
  group shadow_sample
    ../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/samples/scenarized/: exhibitor_shadow_sample.c
software components: CMSIS:CORE 4.3.0
